# Keil uVision project stm32f1xx.uvproj, settings and files
target stm32f1xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f1xx
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 oTime=1 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD
  c include: .\startup\inc;.\app\inc;.\drivers\inc;.\tools\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group startup
    ./startup/: sys.c startup_stm32f10x_hd.s
  group app
    ./app/: main.c runled.c
  group drivers
    ./drivers/: bsp_f1xx_dma.c bsp_f1xx_io.c bsp_f1xx_led.c bsp_f1xx_timer.c bsp_f1xx_uart.c bsp_f1xx_flash.c bsp_f1xx_rtc.c bsp_f1xx_sdio.c datautil.c
  group tools
    ./tools/: malloc.c tskmanager.c bufferutil.c crcutil.c
